options:
  parameters:
    generate_options: qt_gui
    id: Capstone_2621
    output_language: python
    title: Frequency Hopping Spread Spectrum
  states: {}

blocks:
- name: jamming_range
  id: variable_qtgui_range
  parameters:
    label: Jamming Range
    start: '500'
    step: '1'
    stop: 100e4
    value: 500e3
  states: {}
- name: noise_lvl
  id: variable_qtgui_range
  parameters:
    label: Noise Lvl
    start: '0'
    step: '0.01'
    stop: '0.1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4.8e6
  states: {}
- name: vol_lvl
  id: variable_qtgui_range
  parameters:
    label: Volume Lvl
    start: '0'
    step: '0.0001'
    stop: '0.005'
    value: '0.001'
  states: {}
- name: xlate_freq
  id: variable_qtgui_range
  parameters:
    start: '-5e6'
    step: 5e4
    stop: 5e6
    value: '0'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*(5e3)/samp_rate
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '4800000'
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_lvl
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '100'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_throttle2_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '1024'
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: xlate_freq
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ciaran/Downloads/1-04. Welcome To The World of Pokemon! ~ Route 123.mp3
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, samp_rate=1e6, nfft=1024, thresh_db=8.0, publish_every=10):
              gr.sync_block.__init__(
                  self,
                  name="noise_edges_safe",
                  in_sig=[(np.float32, int(nfft))],
                  out_sig=None
              )
              self.samp_rate = float(samp_rate)
              self.nfft = int(nfft)
              self.thresh_db = float(thresh_db)
              self.publish_every = int(publish_every)
              self._count = 0
              self.floor_db = None

              self.message_port_register_out(pmt.intern("edges"))

          def _pub_edges(self, f_lo, f_hi, thr):
              msg = pmt.make_dict()
              msg = pmt.dict_add(msg, pmt.intern("f_lo_hz"), pmt.from_double(float(f_lo)))
              msg = pmt.dict_add(msg, pmt.intern("f_hi_hz"), pmt.from_double(float(f_hi)))
              msg = pmt.dict_add(msg, pmt.intern("thr_db"), pmt.from_double(float(thr)))
              self.message_port_pub(pmt.intern("edges"), msg)

          def work(self, input_items, output_items):
              specs = input_items[0]  # (nvecs, nfft)
              bin_hz = self.samp_rate / self.nfft

              for v in specs:
                  self._count += 1
                  if self.publish_every > 1 and (self._count % self.publish_every) != 0:
                      continue

                  try:
                      p_db = 10.0*np.log10(np.maximum(v, 1e-20))

                      floor_now = np.median(p_db)
                      self.floor_db = floor_now if self.floor_db is None else 0.9*self.floor_db + 0.1*floor_now
                      thr = self.floor_db + self.thresh_db

                      mask = p_db > thr
                      idx = np.where(mask)[0]

                      # NEW: if no jammer detected, publish zeros
                      if idx.size == 0:
                          self._pub_edges(0.0, 0.0, thr)
                          continue

                      splits = np.where(np.diff(idx) > 1)[0] + 1
                      groups = np.split(idx, splits)
                      best = max(groups, key=lambda g: g.size)

                      k_lo, k_hi = int(best[0]), int(best[-1])

                      # FFT-shifted mapping (-Fs/2..Fs/2) IF your FFT is shift=True.
                      f_lo = (k_lo - self.nfft/2) * bin_hz
                      f_hi = (k_hi - self.nfft/2) * bin_hz

                      self._pub_edges(f_lo, f_hi, thr)

                  except Exception:
                      # If something weird happens, publish zeros rather than crashing
                      try:
                          thr_fallback = float(self.floor_db) if self.floor_db is not None else -200.0
                          self._pub_edges(0.0, 0.0, thr_fallback)
                      except Exception:
                          pass

              return len(specs)
    nfft: '1024'
    publish_every: '10000'
    samp_rate: 4.8e6
    thresh_db: '40'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import random
      import threading
      import math
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(
              self,
              seed=12345,
              center_freq_hz=915e6,
              chan_spacing=200e3,
              chan_bw_hz=60e3,
              mute_time_s=0.02,
              guard_hz=2e3,
              num_chans=25,
              max_attempts=128,
              tx_chan=0,
              follow_rx=False,
              active=True,
          ):
              gr.basic_block.__init__(
                  self,
                  name='FHSS hopper (separate TX/RX retune callbacks)',
                  in_sig=None,
                  out_sig=None
              )

              # OUT ports
              self.message_port_register_out(pmt.intern("set_mute"))
              self.message_port_register_out(pmt.intern("rf_freq"))

              # Optional debug ports
              self.message_port_register_out(pmt.intern("tx_freq"))
              self.message_port_register_out(pmt.intern("rx_freq"))

              # IN ports
              self.message_port_register_in(pmt.intern("tick"))
              self.set_msg_handler(pmt.intern("tick"), self._on_tick)

              self.message_port_register_in(pmt.intern("edges"))
              self.set_msg_handler(pmt.intern("edges"), self._on_edges)

              # State
              self.rng = random.Random(int(seed))

              self.center_freq_hz = float(center_freq_hz)
              self.chan_spacing = float(chan_spacing)
              self.chan_bw_hz = float(chan_bw_hz)
              self.mute_time_s = float(mute_time_s)
              self.guard_hz = float(guard_hz)
              self.num_chans = int(num_chans)
              self.max_attempts = int(max_attempts)
              self.tx_chan = int(tx_chan)

              if self.num_chans % 2 == 0:
                  raise ValueError("num_chans should be odd if you want one channel exactly centered at center_freq_hz")

              self.mid_chan = self.num_chans // 2
              self.chan = self.mid_chan

              self.jam_lo = None
              self.jam_hi = None
              self.active = bool(active)
              self.follow_rx = bool(follow_rx)

              self._retune_lock = threading.Lock()
              self._tx_retune_fn = None
              self._rx_retune_fn = None

          # ---------- external hooks ----------
          def set_tx_retune_fn(self, fn):
              self._tx_retune_fn = fn

          def set_rx_retune_fn(self, fn):
              self._rx_retune_fn = fn

          def set_follow_rx(self, follow_rx):
              self.follow_rx = bool(follow_rx)

          def set_active(self, active):
              self.active = bool(active)

          # ---------- publishing helpers ----------
          def _pub_mute(self, state):
              self.message_port_pub(pmt.intern("set_mute"), pmt.to_pmt(bool(state)))

          def _pub_rf_freq(self, freq_hz):
              msg = pmt.cons(pmt.intern("rf_freq"), pmt.from_double(float(freq_hz)))
              self.message_port_pub(pmt.intern("rf_freq"), msg)

          def _pub_tx_freq(self, freq_hz):
              msg = pmt.cons(pmt.intern("tx_freq"), pmt.from_double(float(freq_hz)))
              self.message_port_pub(pmt.intern("tx_freq"), msg)

          def _pub_rx_freq(self, freq_hz):
              msg = pmt.cons(pmt.intern("rx_freq"), pmt.from_double(float(freq_hz)))
              self.message_port_pub(pmt.intern("rx_freq"), msg)

          # ---------- retune helpers ----------
          def _retune_tx_hw(self, freq_hz):
              if self._tx_retune_fn is None:
                  raise RuntimeError("No LimeSDR TX retune callback installed.")
              self._tx_retune_fn(float(freq_hz))

          def _retune_rx_hw(self, freq_hz):
              if self._rx_retune_fn is None:
                  raise RuntimeError("No LimeSDR RX retune callback installed.")
              self._rx_retune_fn(float(freq_hz))

          def _retune_with_mute(self, freq_hz):
              with self._retune_lock:
                  self._pub_mute(True)

                  # Always retune TX
                  self._retune_tx_hw(freq_hz)
                  self._pub_tx_freq(freq_hz)

                  # Only retune RX if enabled
                  if self.follow_rx:
                      self._retune_rx_hw(freq_hz)
                      self._pub_rx_freq(freq_hz)

                  self._pub_rf_freq(freq_hz)
                  threading.Timer(self.mute_time_s, lambda: self._pub_mute(False)).start()

          # ---------- jammer logic ----------
          def _is_no_jammer(self):
              return (
                  self.jam_lo is None or self.jam_hi is None or
                  (self.jam_lo == 0.0 and self.jam_hi == 0.0)
              )

          @staticmethod
          def _overlap(a_lo, a_hi, b_lo, b_hi):
              return (a_lo <= b_hi) and (b_lo <= a_hi)

          def _hop_band(self, f_center):
              half = 0.5 * self.chan_bw_hz
              return (f_center - half - self.guard_hz, f_center + half + self.guard_hz)

          def _hop_overlaps_jam(self, f_center):
              if self._is_no_jammer():
                  return False
              c_lo, c_hi = self._hop_band(f_center)
              return self._overlap(c_lo, c_hi, self.jam_lo, self.jam_hi)

          # ---------- hop grid ----------
          def _grid_freq(self, chan):
              offset_index = int(chan) - self.mid_chan
              return self.center_freq_hz + offset_index * self.chan_spacing

          def _pick_next_chan(self):
              step = self.rng.randint(1, self.num_chans - 1)
              return (self.chan + step) % self.num_chans

          def _nearest_valid_chan_for_freq(self, f_hz):
              offset = f_hz - self.center_freq_hz
              idx = round(offset / self.chan_spacing) + self.mid_chan
              idx = max(0, min(self.num_chans - 1, idx))
              return idx

          def _move_center_to_clear_jam(self, f_center):
              if not self._hop_overlaps_jam(f_center):
                  return f_center

              half = 0.5 * self.chan_bw_hz
              need_below = self.jam_lo - self.guard_hz - half
              need_above = self.jam_hi + self.guard_hz + half

              if abs(f_center - need_below) <= abs(need_above - f_center):
                  chan = self._nearest_valid_chan_for_freq(need_below)
              else:
                  chan = self._nearest_valid_chan_for_freq(need_above)

              return self._grid_freq(chan)

          def _fallback_safe_freq(self):
              for c in range(self.num_chans):
                  f = self._grid_freq(c)
                  if not self._hop_overlaps_jam(f):
                      return f
              return self._grid_freq(self.mid_chan)

          # ---------- message handlers ----------
          def _on_edges(self, msg):
              """
              Expects PMT dict with absolute RF jammer edges:
                  {"f_lo_hz": 914950000.0, "f_hi_hz": 915050000.0}
              """
              try:
                  if not pmt.is_dict(msg):
                      return

                  lo_p = pmt.dict_ref(msg, pmt.intern("f_lo_hz"), pmt.PMT_NIL)
                  hi_p = pmt.dict_ref(msg, pmt.intern("f_hi_hz"), pmt.PMT_NIL)
                  if lo_p is pmt.PMT_NIL or hi_p is pmt.PMT_NIL:
                      return

                  lo = float(pmt.to_double(lo_p))
                  hi = float(pmt.to_double(hi_p))
                  if hi < lo:
                      lo, hi = hi, lo

                  self.jam_lo = lo
                  self.jam_hi = hi
              except Exception:
                  return

          def _on_tick(self, msg):
              if not self.active:
                  self._pub_mute(True)
                  return

              chosen = None
              attempts = 0

              while attempts < self.max_attempts:
                  next_chan = self._pick_next_chan()
                  f = self._grid_freq(next_chan)
                  f2 = self._move_center_to_clear_jam(f)

                  if not self._hop_overlaps_jam(f2):
                      chosen = f2
                      self.chan = self._nearest_valid_chan_for_freq(f2)
                      break

                  attempts += 1

              if chosen is None:
                  chosen = self._fallback_safe_freq()
                  self.chan = self._nearest_valid_chan_for_freq(chosen)

              self._retune_with_mute(chosen)
    active: 'True'
    center_freq_hz: 914e6
    chan_bw_hz: 60e3
    chan_spacing: 100e3
    follow_rx: 'True'
    guard_hz: '1000'
    max_attempts: '128'
    mute_time_s: '1e-2'
    num_chans: '25'
    seed: '1'
    tx_chan: '0'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import os
      import time
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          Capture receiver-side FFT power vectors and persist spectrogram image snippets
          for CNN training. Labels are inferred from observed hops on the RX antenna
          by identifying channels that are not being visited over a rolling hop window.
          """

          def __init__(
              self,
              nfft=1024,
              history_len=128,
              save_every=200,
              out_dir="cnn_training_data",
              samp_rate=4.8e6,
              chan_spacing=200e3,
              chan_bw_hz=60e3,
              num_chans=10,
              hop_history=64,
              min_absence_ratio=0.6,
          ):
              gr.sync_block.__init__(
                  self,
                  name="rx_spectrogram_capture",
                  in_sig=[(np.float32, int(nfft))],
                  out_sig=None,
              )

              self.nfft = int(nfft)
              self.history_len = int(history_len)
              self.save_every = max(1, int(save_every))
              self.out_dir = str(out_dir)
              self.samp_rate = float(samp_rate)
              self.chan_spacing = float(chan_spacing)
              self.chan_bw_hz = float(chan_bw_hz)
              self.num_chans = int(num_chans)
              self.hop_history = max(4, int(hop_history))
              self.min_absence_ratio = float(min_absence_ratio)

              self._rows = []
              self._count = 0
              self._rx_chan_history = []
              self._last_avoid_channels = []
              self.message_port_register_out(pmt.intern("avoid_channels"))

              os.makedirs(self.out_dir, exist_ok=True)

          def _infer_rx_hop_channel(self, p_db):
              df = self.samp_rate / float(self.nfft)
              half_bw_bins = max(1, int(round((0.5 * self.chan_bw_hz) / df)))

              best_chan = None
              best_power = -1e30
              for chan in range(self.num_chans):
                  center_f = chan * self.chan_spacing
                  center_bin = int(round((center_f + (0.5 * self.samp_rate)) / df))

                  lo = max(0, center_bin - half_bw_bins)
                  hi = min(self.nfft, center_bin + half_bw_bins + 1)
                  if hi <= lo:
                      continue

                  avg_p = float(np.mean(p_db[lo:hi]))
                  if avg_p > best_power:
                      best_power = avg_p
                      best_chan = chan

              return best_chan

          def _append_rx_hop_channel(self, chan):
              if chan is None:
                  return
              self._rx_chan_history.append(chan)
              if len(self._rx_chan_history) > self.hop_history:
                  self._rx_chan_history = self._rx_chan_history[-self.hop_history:]
              self._last_avoid_channels = self._infer_avoid_channels()

          def _infer_avoid_channels(self):
              if len(self._rx_chan_history) < self.hop_history:
                  return []

              counts = np.zeros(self.num_chans, dtype=np.int32)
              for ch in self._rx_chan_history:
                  if 0 <= ch < self.num_chans:
                      counts[ch] += 1

              threshold = self.hop_history * (1.0 - self.min_absence_ratio)
              return [int(idx) for idx, c in enumerate(counts) if float(c) <= threshold]

          def _pub_avoid_channels(self):
              vec = pmt.init_u32vector(len(self._last_avoid_channels), self._last_avoid_channels)
              self.message_port_pub(pmt.intern("avoid_channels"), vec)

          def _write_training_pair(self):
              if len(self._rows) < self.history_len:
                  return

              arr = np.asarray(self._rows[-self.history_len:], dtype=np.float32)
              arr = np.nan_to_num(arr, nan=-140.0, posinf=10.0, neginf=-140.0)
              arr = np.clip(arr, -140.0, 10.0)
              # map [-140, 10] dB to [0,255]
              img = ((arr + 140.0) * (255.0 / 150.0)).astype(np.uint8)

              ts = int(time.time() * 1000)
              stem = os.path.join(self.out_dir, f"rx_spec_{ts}_{self._count}")

              # Portable Graymap (PGM): lightweight image format supported by many loaders.
              with open(stem + ".pgm", "wb") as f:
                  header = f"P5\n{self.nfft} {self.history_len}\n255\n".encode("ascii")
                  f.write(header)
                  f.write(img.tobytes())

              chans = list(self._last_avoid_channels)
              with open(stem + ".txt", "w", encoding="utf-8") as f:
                  f.write(f"hop_history={self.hop_history}\n")
                  f.write("avoid_channels=" + ",".join(str(c) for c in chans) + "\n")

              self._pub_avoid_channels()

          def work(self, input_items, output_items):
              specs = input_items[0]
              for v in specs:
                  p_db = 10.0 * np.log10(np.maximum(v, 1e-20))
                  rx_chan = self._infer_rx_hop_channel(p_db)
                  self._append_rx_hop_channel(rx_chan)
                  self._rows.append(p_db)
                  if len(self._rows) > self.history_len:
                      self._rows = self._rows[-self.history_len:]

                  self._count += 1
                  if self._count % self.save_every == 0:
                      self._write_training_pair()

              return len(specs)
    chan_bw_hz: 60e3
    chan_spacing: 200e3
    history_len: '1024'
    hop_history: '64'
    min_absence_ratio: '0.6'
    nfft: '1024'
    num_chans: '10'
    out_dir: '"cnn_trainin_data"'
    samp_rate: 4.8e6
    save_every: '2000'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {state: disabled}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: jamming_range
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_1
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_2
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_3
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_4
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fir_filter_xxx_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '20'
    oversample: '0'
    rf_freq: 914e6
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: samp_rate
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: 15e3
    gain_dB_ch0: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 914e6
    samp_rate: samp_rate
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Transmitter and channel ABOVE. Receiver BELOW
      -----------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"TX Signal"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: tab@0
    name: '"Channel"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Jamming"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"RX Signal after LPF"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"RX Signal before LPF"'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: fff
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("[TOP] snippet running")

      def retune_tx(f):
              print(f"[TOP] retuning TX to {f/1e6:.3f} MHz")
              self.limesdr_sink_0.set_center_freq(f, 0)

      def retune_rx(f):
              print(f"[TOP] retuning RX to {f/1e6:.3f} MHz")
              self.limesdr_source_0.set_center_freq(f, 0)

      self.epy_block_1_0.set_tx_retune_fn(retune_tx)
      self.epy_block_1_0.set_rx_retune_fn(retune_rx)
    section: main_after_init
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: TX and Channel
    label1: RX
    label2: Audio
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: test_tx
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_antenna1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: test_tx
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx_antenna1
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', filter_fft_low_pass_filter_3, '0']
- [analog_nbfm_rx_0, '0', filter_fft_low_pass_filter_4, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_noise_source_x_0, '0', filter_fft_low_pass_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', epy_block_2, '0']
- [blocks_message_strobe_0, strobe, epy_block_1_0, tick]
- [blocks_multiply_const_vxx_1, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_1, '0', limesdr_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_throttle2_0_0, '0', virtual_sink_1, '0']
- [blocks_throttle2_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_throttle2_1, '0', qtgui_waterfall_sink_x_1_0, '0']
- [blocks_var_to_msg_0, msgout, freq_xlating_fir_filter_xxx_2, freq]
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [epy_block_0, edges, epy_block_1_0, edges]
- [fft_vxx_0, '0', blocks_throttle2_0_0_0, '0']
- [fft_vxx_0_0, '0', blocks_throttle2_0_0_0_0, '0']
- [filter_fft_low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_2, '0']
- [filter_fft_low_pass_filter_1, '0', analog_simple_squelch_cc_0, '0']
- [filter_fft_low_pass_filter_2, '0', blocks_multiply_const_vxx_1, '0']
- [filter_fft_low_pass_filter_3, '0', filter_fft_low_pass_filter_2, '0']
- [filter_fft_low_pass_filter_4, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_2, '0', blocks_throttle2_0_0, '0']
- [limesdr_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [limesdr_source_0, '0', filter_fft_low_pass_filter_1, '0']
- [limesdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [limesdr_source_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [rational_resampler_xxx_1, '0', analog_frequency_modulator_fc_0, '0']
- [virtual_source_0, '0', blocks_throttle2_1, '0']
- [virtual_source_0_0_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
