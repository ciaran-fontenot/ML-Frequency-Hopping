options:
  parameters:
    generate_options: qt_gui
    id: Capstone_2621
    output_language: python
    title: Frequency Hopping Spread Spectrum
  states: {}

blocks:
- name: jamming_range
  id: variable_qtgui_range
  parameters:
    label: Jamming Range
    start: '500'
    step: '1'
    stop: 100e4
    value: 500e3
  states: {}
- name: noise_lvl
  id: variable_qtgui_range
  parameters:
    label: Noise Lvl
    start: '0'
    step: '0.01'
    stop: '0.1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4.8e6
  states: {}
- name: vol_lvl
  id: variable_qtgui_range
  parameters:
    label: Volume Lvl
    start: '0'
    step: '0.0001'
    stop: '0.005'
    value: '0.001'
  states: {}
- name: xlate_freq
  id: variable_qtgui_range
  parameters:
    start: '-5e6'
    step: 5e4
    stop: 5e6
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.1'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*(5e3)/samp_rate
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 5e3
    quad_rate: int(48e5)
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_lvl
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_lvl
    type: complex
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_throttle2_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: xlate_freq
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ciaran/Downloads/1-04. Welcome To The World of Pokemon! ~ Route 123.mp3
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, samp_rate=1e6, nfft=1024, thresh_db=8.0, publish_every=10):
              gr.sync_block.__init__(
                  self,
                  name="noise_edges_safe",
                  in_sig=[(np.float32, int(nfft))],
                  out_sig=None
              )
              self.samp_rate = float(samp_rate)
              self.nfft = int(nfft)
              self.thresh_db = float(thresh_db)
              self.publish_every = int(publish_every)
              self._count = 0
              self.floor_db = None

              self.message_port_register_out(pmt.intern("edges"))

          def _pub_edges(self, f_lo, f_hi, thr):
              msg = pmt.make_dict()
              msg = pmt.dict_add(msg, pmt.intern("f_lo_hz"), pmt.from_double(float(f_lo)))
              msg = pmt.dict_add(msg, pmt.intern("f_hi_hz"), pmt.from_double(float(f_hi)))
              msg = pmt.dict_add(msg, pmt.intern("thr_db"), pmt.from_double(float(thr)))
              self.message_port_pub(pmt.intern("edges"), msg)

          def work(self, input_items, output_items):
              specs = input_items[0]  # (nvecs, nfft)
              bin_hz = self.samp_rate / self.nfft

              for v in specs:
                  self._count += 1
                  if self.publish_every > 1 and (self._count % self.publish_every) != 0:
                      continue

                  try:
                      p_db = 10.0*np.log10(np.maximum(v, 1e-20))

                      floor_now = np.median(p_db)
                      self.floor_db = floor_now if self.floor_db is None else 0.9*self.floor_db + 0.1*floor_now
                      thr = self.floor_db + self.thresh_db

                      mask = p_db > thr
                      idx = np.where(mask)[0]

                      # NEW: if no jammer detected, publish zeros
                      if idx.size == 0:
                          self._pub_edges(0.0, 0.0, thr)
                          continue

                      splits = np.where(np.diff(idx) > 1)[0] + 1
                      groups = np.split(idx, splits)
                      best = max(groups, key=lambda g: g.size)

                      k_lo, k_hi = int(best[0]), int(best[-1])

                      # FFT-shifted mapping (-Fs/2..Fs/2) IF your FFT is shift=True.
                      f_lo = (k_lo - self.nfft/2) * bin_hz
                      f_hi = (k_hi - self.nfft/2) * bin_hz

                      self._pub_edges(f_lo, f_hi, thr)

                  except Exception:
                      # If something weird happens, publish zeros rather than crashing
                      try:
                          thr_fallback = float(self.floor_db) if self.floor_db is not None else -200.0
                          self._pub_edges(0.0, 0.0, thr_fallback)
                      except Exception:
                          pass

              return len(specs)
    nfft: '1024'
    publish_every: '10000'
    samp_rate: 4.8e6
    thresh_db: '40'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import random
      import threading
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          FHSS RX controller that follows the transmitter's hopping decisions.

          Inputs (message ports):
            - "tick":     fallback hop trigger (optional; can be disconnected)
            - "tx_freq":  PMT pair ("freq", <double Hz>) from the TX controller

          Outputs (message ports):
            - "freq":      PMT pair ("freq", <double Hz>) to RX Freq Xlating FIR "freq"
            - "set_mute":  PMT bool to Mute block "set_mute"

          Behavior:
            - When a tx_freq arrives, RX mutes, tunes to the *negative* of TX shift,
              then unmutes after mute_time_s.
            - If no tx_freq has been seen yet, it can optionally hop using the RNG
              on ticks (set follow_only=True to disable fallback).
          """
          def __init__(self, seed=12345, chan_spacing=200e3, mute_time_s=0.02, follow_only=True):
              gr.basic_block.__init__(self, name='FHSS RX controller (follows TX)', in_sig=None, out_sig=None)

              # OUT ports
              self.message_port_register_out(pmt.intern("freq"))       # to RX Freq Xlating FIR "freq"
              self.message_port_register_out(pmt.intern("set_mute"))   # to Mute block "set_mute"

              # IN ports
              self.message_port_register_in(pmt.intern("tick"))
              self.set_msg_handler(pmt.intern("tick"), self._on_tick)

              # NEW: follow TX
              self.message_port_register_in(pmt.intern("tx_freq"))
              self.set_msg_handler(pmt.intern("tx_freq"), self._on_tx_freq)

              self.rng = random.Random(int(seed))
              self.chan = 0
              self.chan_spacing = float(chan_spacing)
              self.mute_time_s = float(mute_time_s)
              self.follow_only = bool(follow_only)

              self.active = True
              self._have_tx = False

          def set_active(self, active: bool):
              self.active = bool(active)

          def _pub_freq(self, freq_hz: float):
              msg = pmt.cons(pmt.intern("freq"), pmt.from_double(float(freq_hz)))
              self.message_port_pub(pmt.intern("freq"), msg)

          def _pub_mute(self, state: bool):
              self.message_port_pub(pmt.intern("set_mute"), pmt.to_pmt(bool(state)))

          def _retune_with_mute(self, freq_hz: float):
              # Mute → retune → unmute
              self._pub_mute(True)
              self._pub_freq(freq_hz)
              threading.Timer(self.mute_time_s, lambda: self._pub_mute(False)).start()

          def _on_tx_freq(self, msg):
              """
              Expect a PMT pair like: ( "freq" . <double> )
              from the TX controller. RX uses the opposite sign.
              """
              if not self.active:
                  self._pub_mute(True)
                  self._pub_freq(0.0)
                  return

              try:
                  # Accept either a pair ("freq" . value) or a dict {"freq": value}
                  tx_f = None

                  if pmt.is_pair(msg):
                      key = pmt.car(msg)
                      val = pmt.cdr(msg)
                      if pmt.is_symbol(key) and pmt.symbol_to_string(key) == "freq":
                          tx_f = float(pmt.to_double(val))

                  elif pmt.is_dict(msg):
                      v = pmt.dict_ref(msg, pmt.intern("freq"), pmt.PMT_NIL)
                      if v is not pmt.PMT_NIL:
                          tx_f = float(pmt.to_double(v))

                  if tx_f is None:
                      return

                  self._have_tx = True

                  # TX shifts UP (+). RX must shift DOWN (-TX) to follow.
                  rx_f = -tx_f
                  self._retune_with_mute(rx_f)

              except Exception:
                  # Don't crash the flowgraph on bad messages
                  return

          def _on_tick(self, msg):
              """
              Optional fallback: if you aren't wired to TX messages, or you want RX
              to free-run until it hears TX, it can hop using the same RNG.
              """
              if not self.active:
                  self._pub_mute(True)
                  self._pub_freq(0.0)
                  return

              if self.follow_only and self._have_tx:
                  # Once we're following TX, ignore ticks.
                  return

              # Fallback hop (same sequence as TX if ticks are aligned)
              self.chan = (self.chan + self.rng.randint(1, 7)) % 8
              freq = -self.chan * self.chan_spacing  # RX shifts DOWN
              self._retune_with_mute(freq)
    chan_spacing: 200e3
    follow_only: '1'
    mute_time_s: '10e-3'
    seed: '1'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import random
      import threading
      import math
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(
              self,
              seed=12345,
              chan_spacing=200e3,
              chan_bw_hz=60e3,
              mute_time_s=0.02,
              guard_hz=2e3,
              num_chans=8,
              max_attempts=64
          ):
              gr.basic_block.__init__(self, name='FHSS TX controller (jammer-aware overlap)', in_sig=None, out_sig=None)

              # OUT ports
              self.message_port_register_out(pmt.intern("freq"))
              self.message_port_register_out(pmt.intern("set_mute"))

              # IN ports
              self.message_port_register_in(pmt.intern("tick"))
              self.set_msg_handler(pmt.intern("tick"), self._on_tick)

              self.message_port_register_in(pmt.intern("edges"))
              self.set_msg_handler(pmt.intern("edges"), self._on_edges)

              # state
              self.rng = random.Random(int(seed))
              self.chan = 0
              self.chan_spacing = float(chan_spacing)
              self.chan_bw_hz = float(chan_bw_hz)
              self.mute_time_s = float(mute_time_s)
              self.guard_hz = float(guard_hz)
              self.num_chans = int(num_chans)
              self.max_attempts = int(max_attempts)

              self.jam_lo = None
              self.jam_hi = None
              self.active = True

          # -------- publishing helpers --------
          def set_active(self, active):
              self.active = bool(active)

          def _pub_freq(self, freq_hz):
              msg = pmt.cons(pmt.intern("freq"), pmt.from_double(float(freq_hz)))
              self.message_port_pub(pmt.intern("freq"), msg)

          def _pub_mute(self, state):
              self.message_port_pub(pmt.intern("set_mute"), pmt.to_pmt(bool(state)))

          def _retune_with_mute(self, freq_hz):
              self._pub_mute(True)
              self._pub_freq(freq_hz)
              threading.Timer(self.mute_time_s, lambda: self._pub_mute(False)).start()

          # -------- jammer logic (overlap-based) --------
          def _is_no_jammer(self):
              return (
                  self.jam_lo is None or self.jam_hi is None or
                  (self.jam_lo == 0.0 and self.jam_hi == 0.0)
              )

          def _overlap(self, a_lo, a_hi, b_lo, b_hi):
              return (a_lo <= b_hi) and (b_lo <= a_hi)

          def _hop_band(self, f_center):
              half = 0.5 * self.chan_bw_hz
              return (f_center - half - self.guard_hz, f_center + half + self.guard_hz)

          def _hop_overlaps_jam(self, f_center):
              if self._is_no_jammer():
                  return False
              c_lo, c_hi = self._hop_band(f_center)
              return self._overlap(c_lo, c_hi, self.jam_lo, self.jam_hi)

          # -------- hop grid --------
          def _grid_freq(self, chan):
              return float(chan) * self.chan_spacing

          def _pick_next_chan(self):
              step = self.rng.randint(1, self.num_chans - 1)
              return (self.chan + step) % self.num_chans

          def _move_center_to_clear_jam(self, f_center):
              if not self._hop_overlaps_jam(f_center):
                  return f_center

              half = 0.5 * self.chan_bw_hz
              need_below = self.jam_lo - self.guard_hz - half
              need_above = self.jam_hi + self.guard_hz + half

              if abs(f_center - need_below) <= abs(need_above - f_center):
                  target = need_below
                  snapped = math.floor(target / self.chan_spacing) * self.chan_spacing
              else:
                  target = need_above
                  snapped = math.ceil(target / self.chan_spacing) * self.chan_spacing

              return float(snapped)

          def _fallback_safe_freq(self):
              for c in range(self.num_chans):
                  f = self._grid_freq(c)
                  if not self._hop_overlaps_jam(f):
                      return f
              return 0.0

          # -------- message handlers --------
          def _on_edges(self, msg):
              try:
                  if not pmt.is_dict(msg):
                      return

                  lo_p = pmt.dict_ref(msg, pmt.intern("f_lo_hz"), pmt.PMT_NIL)
                  hi_p = pmt.dict_ref(msg, pmt.intern("f_hi_hz"), pmt.PMT_NIL)
                  if lo_p is pmt.PMT_NIL or hi_p is pmt.PMT_NIL:
                      return

                  lo = float(pmt.to_double(lo_p))
                  hi = float(pmt.to_double(hi_p))
                  if hi < lo:
                      lo, hi = hi, lo

                  self.jam_lo = lo
                  self.jam_hi = hi
              except Exception:
                  return

          def _on_tick(self, msg):
              if not self.active:
                  self._pub_mute(True)
                  self._pub_freq(0.0)
                  return

              chosen = None
              attempts = 0

              while attempts < self.max_attempts:
                  self.chan = self._pick_next_chan()
                  f = self._grid_freq(self.chan)

                  f2 = self._move_center_to_clear_jam(f)

                  if not self._hop_overlaps_jam(f2):
                      chosen = f2
                      break

                  attempts += 1

              if chosen is None:
                  chosen = self._fallback_safe_freq()

              self._retune_with_mute(chosen)
    chan_bw_hz: 60e3
    chan_spacing: 200e3
    guard_hz: '1000'
    max_attempts: '100'
    mute_time_s: '1e-2'
    num_chans: '10'
    seed: '1'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import os
      import time
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          Capture receiver-side FFT power vectors and persist spectrogram image snippets
          for CNN training. Labels are inferred from observed hops on the RX antenna
          by identifying channels that are not being visited over a rolling hop window.
          """

          def __init__(
              self,
              nfft=1024,
              history_len=128,
              save_every=200,
              out_dir="cnn_training_data",
              samp_rate=4.8e6,
              chan_spacing=200e3,
              chan_bw_hz=60e3,
              num_chans=10,
              hop_history=64,
              min_absence_ratio=0.6,
          ):
              gr.sync_block.__init__(
                  self,
                  name="rx_spectrogram_capture",
                  in_sig=[(np.float32, int(nfft))],
                  out_sig=None,
              )

              self.nfft = int(nfft)
              self.history_len = int(history_len)
              self.save_every = max(1, int(save_every))
              self.out_dir = str(out_dir)
              self.samp_rate = float(samp_rate)
              self.chan_spacing = float(chan_spacing)
              self.chan_bw_hz = float(chan_bw_hz)
              self.num_chans = int(num_chans)
              self.hop_history = max(4, int(hop_history))
              self.min_absence_ratio = float(min_absence_ratio)

              self._rows = []
              self._count = 0
              self._rx_chan_history = []
              self._last_avoid_channels = []
              self.message_port_register_out(pmt.intern("avoid_channels"))

              os.makedirs(self.out_dir, exist_ok=True)

          def _infer_rx_hop_channel(self, p_db):
              df = self.samp_rate / float(self.nfft)
              half_bw_bins = max(1, int(round((0.5 * self.chan_bw_hz) / df)))

              best_chan = None
              best_power = -1e30
              for chan in range(self.num_chans):
                  center_f = chan * self.chan_spacing
                  center_bin = int(round((center_f + (0.5 * self.samp_rate)) / df))

                  lo = max(0, center_bin - half_bw_bins)
                  hi = min(self.nfft, center_bin + half_bw_bins + 1)
                  if hi <= lo:
                      continue

                  avg_p = float(np.mean(p_db[lo:hi]))
                  if avg_p > best_power:
                      best_power = avg_p
                      best_chan = chan

              return best_chan

          def _append_rx_hop_channel(self, chan):
              if chan is None:
                  return
              self._rx_chan_history.append(chan)
              if len(self._rx_chan_history) > self.hop_history:
                  self._rx_chan_history = self._rx_chan_history[-self.hop_history:]
              self._last_avoid_channels = self._infer_avoid_channels()

          def _infer_avoid_channels(self):
              if len(self._rx_chan_history) < self.hop_history:
                  return []

              counts = np.zeros(self.num_chans, dtype=np.int32)
              for ch in self._rx_chan_history:
                  if 0 <= ch < self.num_chans:
                      counts[ch] += 1

              threshold = self.hop_history * (1.0 - self.min_absence_ratio)
              return [int(idx) for idx, c in enumerate(counts) if float(c) <= threshold]

          def _pub_avoid_channels(self):
              vec = pmt.init_u32vector(len(self._last_avoid_channels), self._last_avoid_channels)
              self.message_port_pub(pmt.intern("avoid_channels"), vec)

          def _write_training_pair(self):
              if len(self._rows) < self.history_len:
                  return

              arr = np.asarray(self._rows[-self.history_len:], dtype=np.float32)
              arr = np.nan_to_num(arr, nan=-140.0, posinf=10.0, neginf=-140.0)
              arr = np.clip(arr, -140.0, 10.0)
              # map [-140, 10] dB to [0,255]
              img = ((arr + 140.0) * (255.0 / 150.0)).astype(np.uint8)

              ts = int(time.time() * 1000)
              stem = os.path.join(self.out_dir, f"rx_spec_{ts}_{self._count}")

              # Portable Graymap (PGM): lightweight image format supported by many loaders.
              with open(stem + ".pgm", "wb") as f:
                  header = f"P5\n{self.nfft} {self.history_len}\n255\n".encode("ascii")
                  f.write(header)
                  f.write(img.tobytes())

              chans = list(self._last_avoid_channels)
              with open(stem + ".txt", "w", encoding="utf-8") as f:
                  f.write(f"hop_history={self.hop_history}\n")
                  f.write("avoid_channels=" + ",".join(str(c) for c in chans) + "\n")

              self._pub_avoid_channels()

          def work(self, input_items, output_items):
              specs = input_items[0]
              for v in specs:
                  p_db = 10.0 * np.log10(np.maximum(v, 1e-20))
                  rx_chan = self._infer_rx_hop_channel(p_db)
                  self._append_rx_hop_channel(rx_chan)
                  self._rows.append(p_db)
                  if len(self._rows) > self.history_len:
                      self._rows = self._rows[-self.history_len:]

                  self._count += 1
                  if self._count % self.save_every == 0:
                      self._write_training_pair()

              return len(specs)
    chan_bw_hz: 60e3
    chan_spacing: 200e3
    history_len: '1024'
    hop_history: '64'
    min_absence_ratio: '0.6'
    nfft: '1024'
    num_chans: '10'
    out_dir: '"cnn_trainin_data"'
    samp_rate: 4.8e6
    save_every: '2000'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: jamming_range
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Transmitter and channel ABOVE. Receiver BELOW
      -----------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"TX Signal"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Channel"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Jamming"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"RX Signal after LPF"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"RX Signal before LPF"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: TX and Channel
    label1: RX
    label2: Audio
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_antenna
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_antenna1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_antenna
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rx_antenna1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx_antenna1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: rx_antenna
  states: {}

connections:
- [analog_agc_xx_0, '0', audio_sink_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_frequency_modulator_fc_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_nbfm_rx_0, '0', analog_agc_xx_0, '0']
- [analog_noise_source_x_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_add_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', epy_block_2, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, tick]
- [blocks_message_strobe_0, strobe, epy_block_1_0, tick]
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_mute_xx_0, '0', blocks_throttle2_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_throttle2_0_0, '0', virtual_sink_1, '0']
- [blocks_throttle2_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_throttle2_1, '0', analog_nbfm_rx_0, '0']
- [blocks_throttle2_1, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_var_to_msg_0, msgout, freq_xlating_fir_filter_xxx_2, freq]
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, edges, blocks_message_debug_0, print]
- [epy_block_0, edges, epy_block_1_0, edges]
- [epy_block_1, freq, freq_xlating_fir_filter_xxx_0, freq]
- [epy_block_1, set_mute, blocks_mute_xx_0, set_mute]
- [epy_block_1_0, freq, epy_block_1, tx_freq]
- [epy_block_1_0, freq, freq_xlating_fir_filter_xxx_1, freq]
- [fft_vxx_0, '0', blocks_throttle2_0_0_0, '0']
- [fft_vxx_0_0, '0', blocks_throttle2_0_0_0_0, '0']
- [filter_fft_low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_2, '0']
- [filter_fft_low_pass_filter_0_0, '0', blocks_mute_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [freq_xlating_fir_filter_xxx_2, '0', blocks_throttle2_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '1']
- [virtual_source_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_1, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
