options:
  parameters:
    generate_options: qt_gui
    id: Capstone_2621
    output_language: python
    title: Frequency Hopping Spread Spectrum
  states: {}

blocks:
- name: activate_rxer_fhss
  id: variable_qtgui_chooser
  parameters:
    label: Activate RX FHSS
    label0: Deactivate
    label1: Activate
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: activate_txer_fhss
  id: variable_qtgui_chooser
  parameters:
    label: Activate TX FHSS
    label0: Deactivate
    label1: Activate
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: noise_lvl
  id: variable_qtgui_range
  parameters:
    label: Noise Lvl
    start: '0'
    step: '0.01'
    stop: '0.1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4.8e6
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: epy_block_0
    function_args: activate_txer_fhss
    function_name: change_channel
    poll_rate: '1'
    value: '0'
  states: {}
- name: variable_function_probe_0_0
  id: variable_function_probe
  parameters:
    block_id: epy_block_0_0
    function_args: activate_rxer_fhss
    function_name: change_channel
    poll_rate: '1'
    value: '0'
  states: {}
- name: vol_lvl
  id: variable_qtgui_range
  parameters:
    label: Volume Lvl
    start: '0'
    step: '0.0001'
    stop: '0.005'
    value: '0.001'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.1'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*(5e3)/samp_rate
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 5e3
    quad_rate: int(48e5)
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_lvl
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '500'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_lvl
    type: complex
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ciaran/Downloads/1-04. Welcome To The World of Pokemon! ~ Route 123.mp3
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      from datetime import datetime


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_out(pmt.intern("freq"))
              self.channel = 0

          def work(self, input_items, output_items):
              """Useless function"""
              return len(output_items[0])

          def change_channel(self, activate_txer_fhss):
              random.seed(int(datetime.now().timestamp()))
              self.channel = (self.channel + random.randint(1,1000)/100)%8
              if not activate_txer_fhss:
                  P_freq_cmd = pmt.cons(pmt.string_to_symbol("freq"), pmt.from_double(0))
                  self.message_port_pub(pmt.intern("freq"), P_freq_cmd)
                  return
              freq = self.channel * -200e3
              P_freq_cmd = pmt.cons(pmt.string_to_symbol("freq"), pmt.from_double(freq))
              self.message_port_pub(pmt.intern("freq"), P_freq_cmd)
              return 1
    comment: The FHSS Freq Synthesizer for hopping
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      from datetime import datetime


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_out(pmt.intern("freq"))
              self.channel = 0

          def work(self, input_items, output_items):
              """Useless function"""
              return len(output_items[0])

          def change_channel(self, activate_rxer_fhss):  
              random.seed(int(datetime.now().timestamp()))
              self.channel = (self.channel + random.randint(1,1000)/100)%8
              if not activate_rxer_fhss:
                  P_freq_cmd = pmt.cons(pmt.string_to_symbol("freq"), pmt.from_double(0))
                  self.message_port_pub(pmt.intern("freq"), P_freq_cmd)
                  return
              freq = self.channel * 200e3
              P_freq_cmd = pmt.cons(pmt.string_to_symbol("freq"), pmt.from_double(freq))
              self.message_port_pub(pmt.intern("freq"), P_freq_cmd)
              return
    comment: The FHSS Freq Synthesizer for dehopping
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import random
      import threading
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, seed=12345, chan_spacing=200e3, mute_time_s=0.02):
              gr.basic_block.__init__(self, name='FHSS RX controller', in_sig=None, out_sig=None)

              # OUT ports
              self.message_port_register_out(pmt.intern("freq"))       # to Freq Xlating FIR "freq"
              self.message_port_register_out(pmt.intern("set_mute"))   # to Mute block "set_mute"

              # IN port
              self.message_port_register_in(pmt.intern("tick"))
              self.set_msg_handler(pmt.intern("tick"), self._on_tick)

              self.rng = random.Random(int(seed))
              self.chan = 0
              self.chan_spacing = float(chan_spacing)
              self.mute_time_s = float(mute_time_s)

              self.active = True

          def set_active(self, active: bool):
              self.active = bool(active)

          def _pub_freq(self, freq_hz: float):
              msg = pmt.cons(pmt.intern("freq"), pmt.from_double(float(freq_hz)))
              self.message_port_pub(pmt.intern("freq"), msg)

          def _pub_mute(self, state: bool):
              # Mute expects raw PMT bool
              self.message_port_pub(pmt.intern("set_mute"), pmt.to_pmt(bool(state)))

          def _on_tick(self, msg):
              if not self.active:
                  # optional: keep muted + zero shift when inactive
                  self._pub_mute(True)
                  self._pub_freq(0.0)
                  return

              # Next hop (same sequence as TX because same seed + same rng usage)
              self.chan = (self.chan + self.rng.randint(1, 7)) % 8
              freq = -self.chan * self.chan_spacing  # RX shifts DOWN

              # Mute → retune → unmute
              self._pub_mute(True)
              self._pub_freq(freq)
              threading.Timer(self.mute_time_s, lambda: self._pub_mute(False)).start()
    chan_spacing: 200e3
    mute_time_s: '10e-3'
    seed: '1'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import random
      import threading
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, seed=12345, chan_spacing=200e3, mute_time_s=0.02):
              gr.basic_block.__init__(self, name='FHSS TX controller', in_sig=None, out_sig=None)

              # OUT ports
              self.message_port_register_out(pmt.intern("freq"))       # to Freq Xlating FIR "freq"
              self.message_port_register_out(pmt.intern("set_mute"))   # to Mute block "set_mute"

              # IN port
              self.message_port_register_in(pmt.intern("tick"))
              self.set_msg_handler(pmt.intern("tick"), self._on_tick)

              self.rng = random.Random(int(seed))
              self.chan = 0
              self.chan_spacing = float(chan_spacing)
              self.mute_time_s = float(mute_time_s)

              self.active = True

          def set_active(self, active: bool):
              self.active = bool(active)

          def _pub_freq(self, freq_hz: float):
              msg = pmt.cons(pmt.intern("freq"), pmt.from_double(float(freq_hz)))
              self.message_port_pub(pmt.intern("freq"), msg)

          def _pub_mute(self, state: bool):
              self.message_port_pub(pmt.intern("set_mute"), pmt.to_pmt(bool(state)))

          def _on_tick(self, msg):
              if not self.active:
                  self._pub_mute(True)
                  self._pub_freq(0.0)
                  return

              self.chan = (self.chan + self.rng.randint(1, 7)) % 8
              freq = +self.chan * self.chan_spacing  # TX shifts UP

              self._pub_mute(True)
              self._pub_freq(freq)
              threading.Timer(self.mute_time_s, lambda: self._pub_mute(False)).start()
    chan_spacing: 200e3
    mute_time_s: '1e-2'
    seed: '1'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: Emulate narrowband jamming.
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Transmitter and channel ABOVE. Receiver BELOW
      -----------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"TX Signal"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Channel"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"RX Signal after LPF"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"RX Signal before LPF"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: TX and Channel
    label1: RX
    label2: Audio
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_antenna
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_antenna
  states: {}

connections:
- [analog_agc_xx_0, '0', audio_sink_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_frequency_modulator_fc_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_nbfm_rx_0, '0', analog_agc_xx_0, '0']
- [analog_noise_source_x_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, tick]
- [blocks_message_strobe_0, strobe, epy_block_1_0, tick]
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_mute_xx_0, '0', blocks_throttle2_1, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_1, '0', analog_nbfm_rx_0, '0']
- [blocks_throttle2_1, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_1, freq, freq_xlating_fir_filter_xxx_0, freq]
- [epy_block_1, set_mute, blocks_mute_xx_0, set_mute]
- [epy_block_1_0, freq, freq_xlating_fir_filter_xxx_1, freq]
- [filter_fft_low_pass_filter_0, '0', blocks_add_xx_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', blocks_mute_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
